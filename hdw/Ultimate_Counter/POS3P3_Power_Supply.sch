File: hdw/Ultimate_Counter/POS3P3_Power_Supply.sch (KiCad schematic (older format))
At the start: 13 parts

Commit message: Started on schematic
Other:
- moved on the sheet: C?, L?, R?, TP?, U?
